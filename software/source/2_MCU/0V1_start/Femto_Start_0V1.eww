<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Femto_Start_0V1.ewp</path>
  </project>
  <batchBuild/>
</workspace>


