# IAR project Backup of Femto_Start_0V1_DA1D664F_100.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm128.xcl
configuration Release (AVR)
  as the first configuration, except:
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkm128s.xcl
  group (top)
    ./: App_0V1_start2.C
