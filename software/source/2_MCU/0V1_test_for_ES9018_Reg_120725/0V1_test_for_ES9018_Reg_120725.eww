<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\0V1_test_for_ES9018_Reg_120725.ewp</path>
  </project>
  <batchBuild/>
</workspace>


