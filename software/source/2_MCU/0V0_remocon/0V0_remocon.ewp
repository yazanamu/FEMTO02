# IAR project 0V0_remocon.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: tiny13 ATtiny13
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 1
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkm16t.xcl
configuration Release (AVR)
  as the first configuration, except:
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnktiny13t.xcl
  group (top)
    ./: 0V1_remocon_APP.C
