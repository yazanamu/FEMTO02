# IAR project Femto02.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x20
  General.SCCStackSize: 0x40
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m128a ATmega128A
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 1
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm128a.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.GenDeviceSelectMenu: m128 ATmega128
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkm128s.xcl
  group (top)
    ./: ak4118a.c dot_matrix_func.c es9038.c i2c_master.c initboard.c ioport_128.c main.c main_func.c remocon.c uart.c
