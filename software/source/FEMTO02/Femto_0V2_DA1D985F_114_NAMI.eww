<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Femto_0V2_DA1D985F_114_NAMI.ewp</path>
  </project>
  <batchBuild/>
</workspace>


